# Keil uVision project STM32_EnvMonitor_Terminal.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_EnvMonitor_Terminal +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Core;.\Hardware\USART;.\User;.\Libraries\inc;.\Hardware\I2C;.\Hardware\SHT20;.\Hardware\LCD;.\SYSTEM\delay;.\SYSTEM\sys;.\FreeRTOS\FreeRTOS_Config;.\FreeRTOS\FreeRTOS_Core;.\FreeRTOS\FreeRTOS_Port;.\FreeRTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c
  group Core
    ./Core/: startup_stm32f10x_hd.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Hardware
    ./Hardware/USART/: usart.c
    ./Hardware/I2C/: i2c.c
    ./Hardware/SHT20/: sht20.c
    ./Hardware/LCD/: lcd.c
  group Libraries
    ./Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
  group FreeRTOS_Core
    ./FreeRTOS/FreeRTOS_Core/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Port
    ./FreeRTOS/FreeRTOS_Port/: heap_4.c port.c
